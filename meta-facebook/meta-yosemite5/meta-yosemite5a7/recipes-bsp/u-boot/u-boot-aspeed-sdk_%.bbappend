FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://yosemite5a7.cfg"
