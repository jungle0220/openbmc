FILESEXTRAPATHS:prepend := "${THISDIR}/linux-aspeed-sdk:"
SRC_URI += "file://yosemite5a7.cfg"

