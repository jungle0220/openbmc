KBRANCH = "aspeed-master-v6.6"
LINUX_VERSION ?= "6.6.106"

# Tag for v00.06.08
SRCREV = "e7160754cf4487fa36c2e556964c17529462e141"

require linux-aspeed-sdk.inc
